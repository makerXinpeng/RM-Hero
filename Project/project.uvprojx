# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\startup;..\FWLIB\inc;..\user;..\SYSTEM\inc;..\user\user_lib;..\user\DSP\Include;..\user\APP\ChassisMotor;..\user\APP\CloudMotor;..\user\APP\Control_Task;..\user\APP\Encoder;..\user\APP\pid;..\user\APP\remote_control;..\user\APP\shoot;..\user\HARDWARE\adc;..\user\HARDWARE\buzzer;..\user\HARDWARE\can;..\user\HARDWARE\exit_init;..\user\HARDWARE\flash;..\user\HARDWARE\fric;..\user\HARDWARE\laser;..\user\HARDWARE\power_ctrl;..\user\HARDWARE\rc;..\user\HARDWARE\rng;..\user\HARDWARE\spi;..\user\HARDWARE\timer;..\user\judge_sys
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User_lib
    ../user/user_lib/: user_lib.c
  group SYSTEM
    ../SYSTEM/src/: delay.c sys.c usart.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group HARDWARE
    ../user/HARDWARE/adc/: adc.c
    ../user/HARDWARE/buzzer/: buzzer.c
    ../user/HARDWARE/can/: can.c
    ../user/HARDWARE/exit_init/: exit_init.c
    ../user/HARDWARE/flash/: flash.c
    ../user/HARDWARE/fric/: fric.c
    ../user/HARDWARE/laser/: laser.c
    ../user/HARDWARE/power_ctrl/: power_ctrl.c
    ../user/HARDWARE/rc/: rc.c
    ../user/HARDWARE/rng/: rng.c
    ../user/HARDWARE/spi/: spi.c
    ../user/HARDWARE/timer/: timer.c
  group APP
    ../user/APP/ChassisMotor/: ChassisMotor.c
    ../user/APP/CloudMotor/: CloudMotor.c
    ../user/APP/Control_Task/: Control_Task.c
    ../user/APP/Encoder/: Encoder.c
    ../user/APP/pid/: pid.c
    ../user/APP/remote_control/: remote_control.c
    ../user/APP/shoot/: shoot.c
  group main
    ../user/: main.c
  group judge_system
    ../user/judge_sys/: communicate.c data_fifo.c judgement_info.c JudgeSystem.c protocol.c
